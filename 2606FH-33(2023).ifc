Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-01-18T14:32:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jan 18 14:32:38 2024 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\8f7cd2e0-03ab-4ff1-affa-af7c0cebbbaf\af8961c8-f9b3-4c5d-9cba-6bbee88e97f1\ifc * Database version: 5507 * Database creation date: Thu Jan 18 14:32:37 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Jan 18 14:32:37 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jan 18 14:32:37 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 2606FH-33 Oras Optima Style, 2606FH-33(2023):2606FH-33 Oras Optima Style:306691
In: Level 1
Type - PredefinedType: FAUCET; Material: Matt black
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 204.152 mm; FaucetNominalHeight: 197.706 mm; FaucetNominalWidth: 50 mm; HandShowerNominalDepth: 68.2057 mm; HandShowerNominalHeight: 315.44 mm; HandShowerNominalWidth: 45.9 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 2606FH-33(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 18/01/2024
Type - Green Building Properties - EAN Number: 6414150102547; EN Standard: EN 817; ETIM Class Number: EC011328 Washbasin mixing tap; LVI Number: 6110471; Noise Class: I (ISO 3822); NRF Number: 4200677; RSK Number: 8275683; Sales Package dimensions (LxWxH): 590 x 180 x 63; STF Certificate: EUFI29-23002169-TH1; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/2606FH-33; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/185504_2606FH-33_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL STF: http://static.oras.com/STF/2606FH-33; URL UWL: http://static.oras.com/UWL/2606FH-33; VVS Number: 703896211
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/2606FH-33; 3D View: https://static.oras.com/AR/2606FH-33; Catalog Drawing URL: http://static.oras.com/catdrw/2606FH-33; Dimension Drawing URL: http://static.oras.com/dimdrw/2606FH-33; FDV Document URL: http://www.oras.com/datasheet/2606FH-33/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/2606FH-33; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/2606FH-33; Interactive AR View URL: https://static.oras.com/AR/2606FH-33; Manufacturer: Oras; Market: International;Finland;Norway;Sweden;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/2606FH-33; Model: 2606FH-33 Oras Optima Style; Name_en: 2606FH-33 Oras Optima Style; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 2606FH-33; Product Family: null Single-lever;Bidetta; Product Image URL: http://static.oras.com/image/2606FH-33; Product URL: http://static.oras.com/2606FH-33; Spare-Part Information URL: http://static.oras.com/sp/2606FH-33; Technical DataSheet URL: http://www.oras.com/datasheet/2606FH-33/en; Type Name: 2606FH-33 Oras Optima Style; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Matt black
Type - Mechanical - Advanced Features: Inner body made of DZR brass; Aerator: Standard aerator;PCA® - constant flow rate regardless of pressure variations; Backflow Prevention EN1717: HC; Connection: Flexible inlet pipes; Connection Size: G3/8; Excluded Items: Without pop-up waste; Flow Rate At 300kPa With Flow Controller: 0.000353147 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Pin shape;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 30Cartridge; Shower Parts: Hand shower;Shower holder; Spout Projection: 133 mm; Spout Type: Fixed spout; Surface treatment: Matt black; Temperature Adjustments: Limitation option for maximum temperature and flow-rate ;Adjustable hot water stop (included, retrofittable); Working Pressure: 50 - 1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Matt black; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 2606FH-33(2023); Features: Washbasin faucet; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 2606FH-33; Name: 2606FH-33 Oras Optima Style; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:50x144x147 mm / Hand shower: 46x64x286 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0958269 m2; Volume: 0.00288027 m3
Identity Data - Mark: 4
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 2606FH-33(2023): 2606FH-33 Oras Optima Style; Family and Type: 2606FH-33(2023): 2606FH-33 Oras Optima Style; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 2606FH-33(2023): 2606FH-33 Oras Optima Style; Type Id: 2606FH-33(2023): 2606FH-33 Oras Optima Style; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
